# Keil uVision project takecopter_v4.uvproj, settings and files
target takecopter_v4 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: takecopter_v4 +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,RVDS_ARMCM3_LM3S102
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\RTOS\include;..\modules;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group RTOS
    ../RTOS/: list.c port.c queue.c tasks.c timers.c heap_2.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer2_pwm.c
  group modules
    ../modules/: PID.c pwm.c reveiver.c rotors.c sys_init.c att_controller.c USART3_IMU.c
